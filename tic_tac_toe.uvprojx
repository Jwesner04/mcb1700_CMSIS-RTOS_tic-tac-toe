# Keil uVision project tic_tac_toe.uvprojx, settings and files
target Simulator (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  c define: __ADC_IRQ
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group StartUp
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Source Files
    ./: GLCD_SPI_LPC1700.c Retarget.c Serial.c LED.c IRQ.c ADC.c mcb1700_joystick.c main.c
  group Documentation
    ./: Abstract.txt
target LPC1768 RAM (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.1.0
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __USE_LCD __ADC_IRQ
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target LPC1768 Flash (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.1.0
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: __USE_LCD __ADC_IRQ
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0
